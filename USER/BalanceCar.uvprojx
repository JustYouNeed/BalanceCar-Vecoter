# Keil uVision project BalanceCar.uvprojx, settings and files
target BalanceCar (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LED +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\PWM;..\HARDWARE\OLED;..\HARDWARE\MPU6050\eMPL;..\HARDWARE\IIC;..\HARDWARE\MPU6050;..\HARDWARE\BSP_BATTERY;..\HARDWARE\ENCODER;..\HARDWARE\TIMER;..\HARDWARE\KALMAN;..\HARDWARE\MOTOR;..\HARDWARE\SPI;..\HARDWARE\BSP_BLUETOOTH;..\HARDWARE\BalanceCar;..\HARDWARE\24C02
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/IIC/: myiic.c
    ../HARDWARE/BSP_BATTERY/: bsp_battery.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/BSP_BLUETOOTH/: bluetooth.c
  group MPU6050
    ../HARDWARE/MPU6050/: MPU6050.c
    ../HARDWARE/MPU6050/eMPL/: inv_mpu_dmp_motion_driver.c inv_mpu.c
  group MOTOR
    ../HARDWARE/ENCODER/: encoder.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/MOTOR/: motor_control.c motor.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_rtc.c stm32f10x_cec.c stm32f10x_dma.c stm32f10x_flash.c stm32f10x_i2c.c stm32f10x_pwr.c
